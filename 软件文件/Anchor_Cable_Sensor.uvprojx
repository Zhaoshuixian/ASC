# Keil uVision project Anchor_Cable_Sensor.uvprojx, settings and files
target ACS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L432KBUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Anchor_Cable_Sensor +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32L432xx
  c include: .\DRIVER;.\CMSIS;.\USER\Inc;.\IIC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group DRIVER
    ./DRIVER/: bmi160.c bmi160_bsp.c ad7193.c comm.c misc.c uart.c gpio.c i2c.c spi.c wtd.c os.c flash.c
  group USER
    ./USER/Src/: main.c stm32l4xx_hal_msp.c stm32l4xx_it.c
  group NOTE
    ./NOTE/: readme.txt
software components: CMSIS:CORE 5.4.0, Device:STM32Cube HAL:ADC 1.12.0, Device:STM32Cube HAL:Common 1.12.0, Device:STM32Cube HAL:Cortex 1.12.0, Device:STM32Cube HAL:DMA 1.12.0, Device:STM32Cube HAL:EXTI 1.12.0, Device:STM32Cube HAL:Flash 1.12.0, Device:STM32Cube HAL:GPIO 1.12.0, Device:STM32Cube HAL:I2C 1.12.0, Device:STM32Cube HAL:IWDG 1.12.0, Device:STM32Cube HAL:PWR 1.12.0, Device:STM32Cube HAL:RCC 1.12.0, Device:STM32Cube HAL:RTC 1.12.0, Device:STM32Cube HAL:SPI 1.12.0, Device:STM32Cube HAL:TIM 1.12.0, Device:STM32Cube HAL:UART 1.12.0, Device:STM32Cube HAL:USART 1.12.0, Device:STM32Cube HAL:WWDG 1.12.0, Device:Startup 1.3.1
